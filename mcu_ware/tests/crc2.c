/**
 * #######################
 * # GPT LLM Generated file
 * #######################
 */
#include <stdio.h>
#include <stdint.h>
#include <stddef.h>

/* GD3160 polynomial representation used earlier:
   polynomial (omit x^8) = 0x2F, MSB-first shifting. */
#define POLY 0x2Fu

/* Bitwise MSB-first CRC-8 (seed = 0xFF per datasheet for shift method) */
uint8_t crc8_bitwise(const uint8_t *data, size_t len, uint8_t seed) {
    uint8_t crc = seed;
    for (size_t i = 0; i < len; ++i) {
        crc ^= data[i];
        for (int b = 0; b < 8; ++b) {
            if (crc & 0x80) crc = (uint8_t)((crc << 1) ^ POLY);
            else            crc = (uint8_t)(crc << 1);
        }
    }
    return crc;
}

/* Table-driven CRC using an external vendor table.
   This assumes the vendor table uses the index: table[crc ^ byte].
   If the vendor uses a different indexing convention, results will differ. */
uint8_t crc8_vendor_table(const uint8_t *data, size_t len, uint8_t seed, const uint8_t table[256]) {
    uint8_t crc = seed;
    for (size_t i = 0; i < len; ++i) {
        crc = table[crc ^ data[i]];
    }
    return crc;
}

/* Brute-force search for a seed (0..255) that makes vendor table match the
   bitwise CRC for given data and bitwise_seed. */
int find_seed_for_vendor_table(const uint8_t *data, size_t len, const uint8_t table[256],
                               uint8_t bitwise_seed, uint8_t *out_seed) {
    uint8_t target = crc8_bitwise(data, len, bitwise_seed);
    for (int s = 0; s < 256; ++s) {
        uint8_t t = crc8_vendor_table(data, len, (uint8_t)s, table);
        if (t == target) {
            *out_seed = (uint8_t)s;
            return 1;
        }
    }
    return 0;
}

/* === Paste vendor table here ===
   Replace the '0' entries with the 256-byte table from NXP (or other vendor).
   Example: const uint8_t vendor_table[256] = { 0x00, 0x97, ... };
*/
const uint8_t vendor_table[256]  =
{
	0x00, 0x2f, 0x5e, 0x71, 0xbc, 0x93, 0xe2, 0xcd, 0x57, 0x78, 0x09, 0x26, 0xeb, 0xc4, 0xb5, 0x9a,
	0xae, 0x81, 0xf0, 0xdf, 0x12, 0x3d, 0x4c, 0x63, 0xf9, 0xd6, 0xa7, 0x88, 0x45, 0x6a, 0x1b, 0x34,
	0x73, 0x5c, 0x2d, 0x02, 0xcf, 0xe0, 0x91, 0xbe, 0x24, 0x0b, 0x7a, 0x55, 0x98, 0xb7, 0xc6, 0xe9,
	0xdd, 0xf2, 0x83, 0xac, 0x61, 0x4e, 0x3f, 0x10, 0x8a, 0xa5, 0xd4, 0xfb, 0x36, 0x19, 0x68, 0x47,
	0xe6, 0xc9, 0xb8, 0x97, 0x5a, 0x75, 0x04, 0x2b, 0xb1, 0x9e, 0xef, 0xc0, 0x0d, 0x22, 0x53, 0x7c,
	0x48, 0x67, 0x16, 0x39, 0xf4, 0xdb, 0xaa, 0x85, 0x1f, 0x30, 0x41, 0x6e, 0xa3, 0x8c, 0xfd, 0xd2,
	0x95, 0xba, 0xcb, 0xe4, 0x29, 0x06, 0x77, 0x58, 0xc2, 0xed, 0x9c, 0xb3, 0x7e, 0x51, 0x20, 0x0f,
	0x3b, 0x14, 0x65, 0x4a, 0x87, 0xa8, 0xd9, 0xf6, 0x6c, 0x43, 0x32, 0x1d, 0xd0, 0xff, 0x8e, 0xa1,
	0xe3, 0xcc, 0xbd, 0x92, 0x5f, 0x70, 0x01, 0x2e, 0xb4, 0x9b, 0xea, 0xc5, 0x08, 0x27, 0x56, 0x79,
	0x4d, 0x62, 0x13, 0x3c, 0xf1, 0xde, 0xaf, 0x80, 0x1a, 0x35, 0x44, 0x6b, 0xa6, 0x89, 0xf8, 0xd7,
	0x90, 0xbf, 0xce, 0xe1, 0x2c, 0x03, 0x72, 0x5d, 0xc7, 0xe8, 0x99, 0xb6, 0x7b, 0x54, 0x25, 0x0a,
	0x3e, 0x11, 0x60, 0x4f, 0x82, 0xad, 0xdc, 0xf3, 0x69, 0x46, 0x37, 0x18, 0xd5, 0xfa, 0x8b, 0xa4,
	0x05, 0x2a, 0x5b, 0x74, 0xb9, 0x96, 0xe7, 0xc8, 0x52, 0x7d, 0x0c, 0x23, 0xee, 0xc1, 0xb0, 0x9f,
	0xab, 0x84, 0xf5, 0xda, 0x17, 0x38, 0x49, 0x66, 0xfc, 0xd3, 0xa2, 0x8d, 0x40, 0x6f, 0x1e, 0x31,
	0x76, 0x59, 0x28, 0x07, 0xca, 0xe5, 0x94, 0xbb, 0x21, 0x0e, 0x7f, 0x50, 0x9d, 0xb2, 0xc3, 0xec,
	0xd8, 0xf7, 0x86, 0xa9, 0x64, 0x4b, 0x3a, 0x15, 0x8f, 0xa0, 0xd1, 0xfe, 0x33, 0x1c, 0x6d, 0x42
};

int main(void) {
    const uint8_t msg[] = { 0x12, 0x34, 0x56, 0x78 }; /* example test payload */
    size_t len = sizeof(msg);

    uint8_t bitwise_seed = 0xFF; /* shift/bitwise seed from datasheet */
    uint8_t crc_bit = crc8_bitwise(msg, len, bitwise_seed);
    printf("Bitwise CRC (seed 0x%02X): 0x%02X\n", bitwise_seed, crc_bit);

    /* Test vendor-specified LUT seed 0x42 */
    uint8_t vendor_seed = 0x42;
    uint8_t crc_vendor = crc8_vendor_table(msg, len, vendor_seed, vendor_table);
    printf("Vendor-LUT CRC (seed 0x%02X): 0x%02X\n", vendor_seed, crc_vendor);

    if (crc_vendor == crc_bit) {
        puts("Vendor LUT with seed 0x42 MATCHES bitwise result -> OK.");
    } else {
        puts("Vendor LUT with seed 0x42 DOES NOT match bitwise result for this vector.");
        /* try to find a seed experimentally */
        uint8_t found;
        if (find_seed_for_vendor_table(msg, len, vendor_table, bitwise_seed, &found)) {
            printf("Experimental: found seed 0x%02X that makes vendor LUT match bitwise for this vector.\n", found);
        } else {
            puts("Experimental: no seed in 0..255 made the vendor table match the bitwise CRC for this vector.");
            puts("This likely means the vendor table uses a different byte/bit convention (reflection, indexing, final XOR).");
        }
    }

    return 0;
}
